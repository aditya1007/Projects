# Keil uVision project Project_2.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.12.0
  cpu: IROM(0x00000000,0x00020000) IRAM(0x1FFFF000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project_2
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c misc: --fpmode=fast
  c include: .\Source
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source
    ./Source/: LEDs.c main.c mma8451.c delay.c i2c.c LPTimer.c
software components: CMSIS:CORE 5.0.1, Device:Startup 2.5.0
